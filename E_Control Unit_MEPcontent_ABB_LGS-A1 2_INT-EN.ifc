Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-04-12T15:37:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 12 15:37:47 2018 * Host: B3ROBRAWR3853 * Database: C:\Users\LC\AppData\Local\Temp\{B9837F76-8763-486A-9B75-23E7B0AD06D9}\ifc * Database version: 5507 * Database creation date: Thu Apr 12 15:37:45 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Apr 12 15:37:45 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 12 15:37:45 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: LGS-A1.2, E_Control Unit_MEPcontent_ABB_LGS-A1 2_INT-EN:LGS-A1.2:1323565
In: V00
Type - Material: Color RGB 004-191-009, Color RGB 240-240-240, Color RGB 140-140-140
Type - Dimensions - Depth: 31 mm; Height: 74 mm; Rotation U-Axis Correction: 270 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 180 deg; Width: 74 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Electrical - Loads - Power: 0.012 W
Type - Electrical Engineering - Connection Voltage: 30 V
Type - Identity Data - Article Description: LGS/A1.2 Air Quality Sensor with RTC, SM; Article Type: LGS/A1.2; Category: EL_BUSSYSTEM_SENSOR; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: LGS/A1.2 Air Quality Sensor with RTC, SM; EMCS Version: 3.0; ETIM Article Class: EC000926; Family Version: 11.14; GTIN: 4016779015714; Manufacturer: ABB; Manufacturer Art. No.: 2CDG120059R0011; Manufacturer URL: https://new.abb.com/products/2CDG120059R0011; MEPcontent Class: CONTROL_UNIT; Model: LGS/A1.2; OmniClass Number: 23.60.50.00; OmniClass Title: General Purpose Controls; Product Line: KNX - Heating, Ventilation and Air Conditioning - Environmental Sensors; Revit Version: 2016; Type Name: LGS-A1.2; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Communication Devices; Family Name: E_Control Unit_MEPcontent_ABB_LGS-A1 2_INT-EN
Pset_BuildingElementProxyCommon - Reference: LGS-A1.2; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Offset: 0 mm
Dimensions - Area: 0.0150457 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000106839 m3
Identity Data - Design Option: Main Model; Function Code: E6222BS; Mark: 2
Other - Family: E_Control Unit_MEPcontent_ABB_LGS-A1 2_INT-EN: LGS-A1.2; Family and Type: E_Control Unit_MEPcontent_ABB_LGS-A1 2_INT-EN: LGS-A1.2; Type: E_Control Unit_MEPcontent_ABB_LGS-A1 2_INT-EN: LGS-A1.2; Type Id: E_Control Unit_MEPcontent_ABB_LGS-A1 2_INT-EN: LGS-A1.2
Phasing - Phase Created: 3. Nieuwbouw
